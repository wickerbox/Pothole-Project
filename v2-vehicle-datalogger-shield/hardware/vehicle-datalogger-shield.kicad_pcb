# Repository wickerbox/Pothole-Project

File README.md:

# Pothole Project
Developing a low-cost device to collect and report real-time road information for cities. 

#### Step 1

Arduino 101 Shield using Fona, OBD-II/CAN circuitry, and an SD card. The board schematic was designed but not reviewed; the board was never laid out. 

Next step: lay out the board in KiCad and assemble a prototype

#### Step 2 

Standalone board using Fona, Curie chip, OBD-II/CAN circuitry, and an SD card. Ideally, it would fit into port so it could be left there to just do its thing.

## KiCad design v2-vehicle-datalogger-shield/hardware/vehicle-datalogger-shield.kicad_pcb

File v2-vehicle-datalogger-shield/README.md:

# Pothole Project
## Vehicle Datalogger Shield v1.0 

This shield is heavily based on the OBDII-UART adapter board from Sparkfun and ScanTool, but it adds headers for the Fona 808 2G + GPS breakout board and CC3000 Wifi breakout board, and provides an onboard miniSD holder for datalogging.  

### Bill of Materials

Parts:
C1: 100nF; 0603
C2: 1uF; 0805
D1: MBRA140; SMA_Standard
J1: DB9 TO ENGINE CONTROL UNIT; DB9FC
J2: CC3000-HUZZAH; CC3000BKOUT
J3: FONA808-GPS; Pin_Header_Straight_1x16
J4: CONN-SD-CARD-PUSH-PULL-R/A-SMD; SD_Holder_FullSize
LED1: RED; 0603
Q1: BSS138; SOT-23-3
R1: 866; 0402
R2: 374; 0402
R3: 240; 0402
R4: 1K; 0402
U1: LM317MDT; DPAK
U2: ARDUINO-101-SHIELD
U3, U4, U5, U6: HOLE; ARDUINO-MOUNTING-HOLE

Connections:
+3V3: J2.2 (3V3), J3.4 (Vio), J4.4 (VCC), U2.3V3 (3.3V), U2.AREF; also elsewhere on the board
/A0(WIFI_IRQ): J2.9 (IRQ), U2.A0
/A1(FONA_KEY): J3.9 (KEY), U2.A1
/A2(FONA_TX): J3.7 (TX), U2.A2
/A3(FONA_RX): J3.6 (RX), U2.A3
/A4(WIFI_CS): J2.7 (CS), U2.A4
/D4(WIFI_VBEN): J2.8 (VBEN), U2.D4
/D5(FONA_RST): J3.5 (RST), U2.D5
/D6(FONA_NS): J3.12 (NS), U2.D6
/D7(FONA_PS): J3.11 (PS), U2.D7
/D8(FONA_RTS): J3.8 (RTS), U2.D8
/D9(FONA_RI): J3.10 (RI), U2.D9
/D10(SD_CS): J4.1 (CS), U2.D10
/D11(MOSI): J2.6 (MOSI), J4.2 (DATA_IN), U2.D11
/D12(MISO): J2.5 (MISO), J4.7 (DATA_OUT), U2.D12
/D13(SCLK): J2.4 (CLK), J4.5 (SCLK), U2.D13
CAN_HI: J1.3; also elsewhere on the board
CAN_LO: J1.5; also elsewhere on the board
D2(OBD2_TX): U2.D2; also elsewhere on the board
D3(OBD2_RX): U2.D3; also elsewhere on the board
GND: C1.2, C2.2, J1.1, J1.2, J2.1 (GND), J3.3 (GND), J4.3 (VSS), J4.6 (VSS), J4.13 (GND), LED1.1 (K), Q1.2 (S), R2.2, U2.GND1 (GND), U2.GND2 (GND), U2.GND3 (GND); also elsewhere on the board
J1850BUS+: J1.7; also elsewhere on the board
J1850BUS-: J1.6; also elsewhere on the board
K_LINE: J1.4; also elsewhere on the board
L_LINE: J1.8; also elsewhere on the board
unnamed: D1.2 (A), J1.9
unnamed: LED1.2 (A), R4.2
unnamed: Q1.3 (D), R1.2, R2.1
unnamed: R1.1, R3.2, U1.1 (ADJ)
OBD2_PWM/~VPN: Q1.1 (G); also elsewhere on the board
VBAT: C1.1, D1.1 (K), U1.3 (IN); also elsewhere on the board

Notes on the sheet:
Arduino 101 Shield Mounting Holes
microSD Card for logging data. Needs to support R/W for data access.
Officially 12V, but very noisy. Could be up to 14V or higher with higher input spikes.
REGULATED OUTPUT FROM ARDUINO 101
100V
Adjustable by OBD2_PWM/~VPN (5.76V or 7.71V)
ARDUINO 101

Parts:
C3: 100nF; 0603
D2, D3: BAS16; SOD-323
LED2, LED4: RED; 0603
LED3, LED5: YEL; 0603
Q2, Q5, Q6: MMBT2222; SOT-23-3
Q3: BSS138; SOT-23-3
Q4: ZXMP6A13FTA; SOT-23-3
R5, R6, R10, R11, R14, R15, R16, R19, R23, R24, R26: 10K; 0402
R7: 1.2K; 0402
R8, R27, R32: 4.7K; 0402
R9, R20, R22: 1K; 0402
R12, R21: 510 1/2W; 2010
R13, R33: 1.5K; 0402
R17, R18: RES-10K-1%-1/10W-0402; 0402
R25: 62K; 0402
R28, R29, R30, R31: 330; 0402
U7: LM339PWR; TSSOP-14_4.4x5mm_Pitch0.65mm
U8: STN1110; QFN-32-1EP_5x5mm_Pitch0.5mm
U9: MCP2551; SOIC-8_3.9x4.9mm_Pitch1.27mm
W1, W2, W3: TEST_1P; Pin_Header_Straight_1x01
X1: 16MHz 18pF; CRYSTAL-CTS-4SMD

Connections:
+3V3: LED2.2 (A), LED3.2 (A), LED4.2 (A), LED5.2 (A), R17.1, R18.1, R19.1, U8.10 (VDD), U8.25 (AVDD); also elsewhere on the board
/Vehicle Datalogger/CAN_RX: U8.11 (CAN_RX), U9.4 (ROUT)
/Vehicle Datalogger/CAN_TX: R33.2, U8.12 (CAN_TX), U9.1 (TIN)
/Vehicle Datalogger/J1850BUS+_TX: Q3.1 (G), U8.3 (J1850BUS+_TX)
/Vehicle Datalogger/J1850BUS-_TX: R22.2, U8.4 (J1850BUS-_TX)
/Vehicle Datalogger/OBD_RX_STATUS/PGC: R29.2, U8.19 (~OBD_RX_LED~/~INT)
/Vehicle Datalogger/PWM_RX: R17.2, U7.1, U8.2 (PWM_RX)
/Vehicle Datalogger/RESET: R24.2, U8.26 (RESET), W1.1
/Vehicle Datalogger/RST_NUM: R28.2, U8.18 (~OBD_TX_LED~/~RST_NUM)
/Vehicle Datalogger/SLEEP: U8.9 (SLEEP), W2.1
/Vehicle Datalogger/~ISO_K_TX: R9.2, U8.22 (~ISO_K_TX)
/Vehicle Datalogger/~ISO_L_TX: R20.2, U8.23 (~ISO_L_TX)
/Vehicle Datalogger/~ISO_RX: R19.2, U7.14, U8.8 (~ISO_RX)
/Vehicle Datalogger/~PWR_CTRL: U8.15 (~PWR_CTRL), W3.1
/Vehicle Datalogger/~VPW_RX: R18.2, U7.2, U8.1 (~VPW_RX)
CAN_HI: U9.7 (CANH); also elsewhere on the board
CAN_LO: U9.6 (CANL); also elsewhere on the board
D2(OBD2_TX): U8.14 (UART_TX); also elsewhere on the board
D3(OBD2_RX): R32.2, U8.13 (UART_RX); also elsewhere on the board
GND: C3.2, Q2.2 (E), Q3.2 (S), Q5.2 (E), Q6.2 (E), R6.2, R8.2, R16.2, R26.2, R27.2, U7.12 (-), U8.5 (VSS), U8.16 (VSS), U8.24 (AVSS), U9.2 (GND), X1.2 (GND), X1.4 (GND); also elsewhere on the board
J1850BUS+: R10.2, R14.2; also elsewhere on the board
J1850BUS-: Q6.3 (C), R11.2, R23.2; also elsewhere on the board
K_LINE: Q2.3 (C), R12.2, R15.2; also elsewhere on the board
L_LINE: Q5.3 (C), R21.2; also elsewhere on the board
unnamed: D2.1 (K), R16.1
unnamed: D2.2 (A), Q4.2
unnamed: D3.1 (K), R23.1
unnamed: LED2.1 (K), R28.1
unnamed: LED3.1 (K), R29.1
unnamed: LED4.1 (K), R30.1
unnamed: LED5.1 (K), R31.1
unnamed: Q2.1 (B), R9.1
unnamed: Q3.3 (D), Q4.1, R13.2
unnamed: Q5.1 (B), R20.1
unnamed: Q6.1 (B), R22.1
unnamed: R5.2, R6.1, U7.9 (+)
unnamed: R7.2, R8.1, U7.5 (+)
unnamed: R10.1, U7.7 (+)
unnamed: R11.1, U7.6 (-)
unnamed: R14.1, U7.4 (-)
unnamed: R15.1, U7.8 (-)
unnamed: R25.2, R26.1, U8.27 (ANALOG_IN)
unnamed: R27.1, U9.8 (RS)
unnamed: R30.2, U8.20 (~UART_TX_LED)
unnamed: R31.2, U8.21 (~UART_RX_LED)
unnamed: U8.6 (OSC1), X1.1 (EN)
unnamed: U8.7 (OSC2), X1.3 (OUT)
OBD2_PWM/~VPN: U8.28 (PWM/~VPW); also elsewhere on the board
VBAT: R5.1, R12.1, R21.1, R25.1, U7.3 (+); also elsewhere on the board

Notes on the sheet:
J1850 Transceiver
ISO Transceiver
CAN Transceiver
STN1110 OBD Controller

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
Board: 2 copper layers, 68.6 x 53.3 mm, 68 parts (0 on the bottom side), 70 nets.

Other parts of the board:
C4: 1uF; 0805

Their connections:
GND: C4.2; also elsewhere on the board
VBAT: C4.1; also elsewhere on the board

File v2-vehicle-datalogger-shield/hardware/vehicle-datalogger-shield_BOM.csv:

'Reference','Qty','Description','MF_Name','MF_PN','Digikey'
'C1,C2','2','CAP CER 0.1UF 100V X7R 0603','Murata','GRM188R72A104KA35D','490-3285-1-ND'
'C3,C4','2','CAP CER 1UF 25V X7R 0805','Samsung','CL21B105KAFNNNE','1276-1066-1-ND'
'D1','1','DIODE SCHOTTKY 40V 1A MBRA140 SMA','Vishay','VS-MBRA140TRPBF','VS-MBRA140TRPBFCT-ND'
'D2,D3','2','DIODE GEN PURP 75V 250MA BAS16 SOD323','Vishay','BAS16WS-E3-08','BAS16WS-E3-08CT-ND'
'J1','1','CONN FEMALE DB9 SERIAL TH 9PIN','TE Conn','1734354-1','A35107-ND'
'J2','1','ADAFRUIT CC3000 WIFI BREAKOUT  V1.1','Adafruit','CC3000','1469'
'J3','1','ADAFRUIT FONA 808 + GPS','Adafruit','FONA808+GPS','2542'
'J4','1','CONN SD CARD PUSH-PULL R/A SMD','TE Conn','2041021-4','A101492CT-ND'
'LED1-LED5','5','LED RED DIFFUSED 0603 SMD','Broadcom','HSMS-C191','516-3074-1-ND'
'Q1,Q3','2','MOSFET N-CH 50V 220MA SOT-23','Fairchild','BSS138','BSS138CT-ND'
'Q2,Q5,Q6','1','TRANS NPN 40V 0.6A SOT23','ON Semi','MMBT2222ALT1G','MMBT2222ALT1GOSCT-ND'
'Q4','1','MOSFET P-CH 20V 2.6A SOT23','Infineon','IRLML2246TRPBF','IRLML2246TRPBFCT-ND'
'R1','1','RES SMD 866 OHM 1% 1/10W 0402','Panasonic','ERJ-2RKF8660X','P866LCT-ND'
'R12,R21','2','RES SMD 510 OHM 5% 1/2W 2010','Rohm Semi','MCR50JZHJ511','RHM510BGCT-ND'
'R13,R33','2','RES SMD 1.5K OHM 1% 1/10W 0402','Panasonic','ERJ-2RKF1501X','P1.50KLCT-ND'
'R2','1','RES SMD 374 OHM 1% 1/10W 0402','Panasonic','ERJ-2RKF3740X','P374LCT-ND'
'R25','1','RES SMD 62K OHM 1% 1/10W 0402','Panasonic','ERJ-2RKF6202X','P62.0KLCT-ND'
'R28-R31','4','RES SMD 330 OHM 1% 1/10W 0402','Panasonic','ERJ-2RKF3300X','P330LCT-ND'
'R3','1','RES SMD 240 OHM 1% 1/10W 0402','Panasonic','ERJ-2RKF2400X','P240LCT-ND'
'R4,R9,R20,R22','4','RES SMD 1K OHM 1% 1/10W 0402','Panasonic','ERJ-2RKF1001X','P1.00KLCT-ND'
'R5,R6,R10,R11,R14-R19,R23, R24,R26','13','RES SMD 10K OHM 1% 1/10W 0402','Panasonic','ERJ-2RKF1002X','P10.0KLCT-ND'
'R7','1','RES SMD 1.2K OHM 1% 1/10W 0402','Panasonic','ERJ-2RKF1201X','P1.20KLCT-ND'
'R8,R27,R32','3','RES SMD 4.7K OHM 1% 1/10W 0402','Panasonic','ERJ-2RKF4701X','P4.70KLCT-ND'
'U1','1','IC REG LDO ADJ 0.5A DPAK','STM','LM317MDT-TR','497-1574-1-ND'
'U2','1','ARDUINO 101 SHIELD','Arduino','UNO R3','50'
'U7','1','IC QUAD DIFF COMPARATOR 14-TSSOP','TI','LM339PWR','296-6607-1-ND'
'U8','1','STN1110 OBD-II TO UART IC','ScanTool','STN1110-QFN28','365121'
'U9','1','IC TRANSCEIVER CAN HI-SPD 8-SOIC','Microchip','MCP2551-I/SN','MCP2551-I/SN-ND'
'X1','1','16MHz ±30ppm Crystal 18pF 40 Ohm 4SMD NOLEAD','CTS','406I35D16M00000','CTX1206CT-ND'

## KiCad design v1-breakout-shield/hardware/curie-breakout-shield.kicad_pcb

File v1-breakout-shield/README.md:

# Pothole Project
## Hardware v1.0 

This is a simple breakout board to attach an OBDII-UART adapter board, Fona 808 2G + GPS breakout board, and an SD card to the Arduino 101. 

### Bill of Materials

|Part|Source|Link|
|----|------|----|
|Arduino 101|Adafruit|<a href="https://www.adafruit.com/products/3033">$39.95</a>|
|Fona 808 2G + GPS Breakout Board|Adafruit|<a href="https://www.adafruit.com/products/2542">$49.95</a>|
|OBDII-UART Adapter Board|Sparkfun|<a href="https://www.sparkfun.com/products/9555">$49.95</a>
|SD Card holder|Digikey|<a href="http://www.digikey.com/product-search/en?keywords=A101492CT-ND">$3.10</a>|
|1x06 0.1" pitch female header|Digikey|<a href="http://www.digikey.com/product-search/en?keywords=952-1808-ND">$0.97</a>|
|1x16 0.1" pitch female header|Digikey|<a href="http://www.digikey.com/product-detail/en/sullins-connector-solutions/PPPC161LFBN-RC/S7049-ND/810188">$1.27</a>|

The printed board is a 2 layer board of 2.71x2.11 inches (69x53mm). $28.45 for three.

Board: 2 copper layers, 68.6 x 53.3 mm, 14 parts (0 on the bottom side), 23 nets.

Parts:
J1: CONN-SD-CARD-PUSH-PULL-R/A-SMD; SD_Holder_FullSize
J2: FONA808-GPS; Pin_Header_Straight_1x16
J3: OBDII-UART; Pin_Header_Straight_1x06
U1, U2, U3, U4: HOLE; ARDUINO-MOUNTING-HOLE
U5: ARDUINO-101-SHIELD
W1: D0; TestHole_1x01
W2: A0; TestHole_1x01
W3: D1; TestHole_1x01
W4: A4; TestHole_1x01
W5: D4; TestHole_1x01
W6: A5; TestHole_1x01

Connections:
+3V3: J1.4, J2.4, U5.3V3, U5.AREF
+5V: J2.1, U5.5V
/A0: U5.A0, W2.1
/A1(FONA_KEY): J2.9, U5.A1
/A2(FONA_TX): J2.7, U5.A2
/A3(FONA_RX): J2.6, U5.A3
/A4: U5.A4, U5.SDA, W4.1
/A5: U5.A5, U5.SCL, W6.1
/D0: U5.D0, W1.1
/D1: U5.D1, W3.1
/D2(OBD2_TX): J3.2, U5.D2
/D3(OBD2_RX): J3.3, U5.D3
/D4: U5.D4, W5.1
/D5(FONA_RST): J2.5, U5.D5
/D6(FONA_NS): J2.12, U5.D6
/D7(FONA_PS): J2.11, U5.D7
/D8(FONA_RTS): J2.8, U5.D8
/D9(FONA_RI): J2.10, U5.D9
/D10(SD_CS): J1.1, U5.D10
/D11(MOSI): J1.2, U5.D11
/D12(MISO): J1.7, U5.D12
/D13(SCLK): J1.5, U5.D13
GND: J1.3, J1.6, J1.13, J2.3, J3.6, U5.GND1, U5.GND2, U5.GND3

## Commit log

2016-05-03 Added schematic for very first breakout board shield, because protoboards suck.
2016-05-03 Ordered the breakout board v1.0 from OSH Park.
2016-05-03 Starting the vehicle datalogger shield with everything on board.
2016-05-04 Nearly done. Just need to add CC3000 and verify connections.
2016-05-04 Added CC3000 and fixed all other packages. Ready for check.
2016-05-06 Added generated BOM and README.
2016-05-06 Added OSH Preview.
2016-05-06 Argh, README fixes.
2016-05-06 Typo!
2016-05-06 Pothole vehicle datalogger shield v1.0 schematic is done.
2016-05-10 Added missing footprints, finished symbol-footprint association.
2016-05-15 Updated schematic, BOM, and spread out footprints. Ready to layout.
2016-05-15 New pic of BOM.
2016-05-15 Hopefully added new BOM picture.
2016-10-11 Backing up. Not sure what this commit is.
2016-10-15 Figuring out where this project is at.

Notices in the files:
v1-breakout-shield/hardware/curie-breakout-shield.kicad_pcb:
Released under the CERN Open Hardware License v1.2
